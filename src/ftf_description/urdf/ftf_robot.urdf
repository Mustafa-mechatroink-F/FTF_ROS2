Commit message: Hier deine Nachricht eintragen

File: src/ftf_description/urdf/ftf_robot.urdf (robot description, URDF)
Before this commit: robot ftf_robot, 4 links, 3 joints
Joints:
- joint laser_joint: origin xyz=0.42 0.0 0.15 rpy=3.14159 0 0 -> xyz=0.42 0.0 0.15 rpy=0 0 0
